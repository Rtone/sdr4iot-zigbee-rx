options:
  parameters:
    author: thibaud
    generate_options: no_gui
    id: gr_zigbee
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 2.405e9+5e6*(zigbee_channel-11)
  states: {}
- name: duration_seconds
  id: variable
  parameters:
    value: '10'
  states: {}
- name: freq_channel
  id: variable
  parameters:
    value: center_freq
  states: {}
- name: iq_output
  id: variable
  parameters:
    comment: Filename for I/Q output.
    value: '"zigbee.sigmf-data"'
  states: {}
- name: num_samples
  id: variable
  parameters:
    value: duration_seconds*samp_rate
  states: {}
- name: pcap_file
  id: variable
  parameters:
    value: '"zigbee.cap"'
  states: {}
- name: rf_gain
  id: variable
  parameters:
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: squelch_threshold
  id: variable
  parameters:
    value: '-70'
  states: {}
- name: zigbee_channel
  id: variable
  parameters:
    value: '15'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: iq_output
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: zigbee.cap
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(num_samples)
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.03'
    gain_omega: '0.000225'
    mu: '0.5'
    omega: '2'
    omega_relative_limit: '0.0002'
    type: float
  states: {}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'True'
    tech: '195'
  states: {}
- name: ieee802_15_4_packet_sink_1
  id: ieee802_15_4_packet_sink
  parameters:
    th: '10'
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '0.00016'
    type: float
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: center_freq
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: rf_gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', blocks_sub_xx_0, '0']
- [analog_quadrature_demod_cf_0, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_head_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_sub_xx_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', ieee802_15_4_packet_sink_1, '0']
- [foo_wireshark_connector_0, '0', blocks_file_sink_0_0, '0']
- [ieee802_15_4_packet_sink_1, out, blocks_message_debug_0, print]
- [ieee802_15_4_packet_sink_1, out, blocks_message_debug_0, print_pdu]
- [ieee802_15_4_packet_sink_1, out, foo_wireshark_connector_0, in]
- [single_pole_iir_filter_xx_0, '0', blocks_sub_xx_0, '1']
- [uhd_usrp_source_0, '0', blocks_head_0, '0']

metadata:
  file_format: 1
